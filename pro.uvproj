# Keil uVision project pro.uvproj, settings and files
target Playground (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: pro +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group src
    ./: main.c
